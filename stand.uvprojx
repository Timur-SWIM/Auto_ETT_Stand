# Keil uVision project stand.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.3.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stand +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -Wno-unused-parameter
  c include: ,.\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./src/: adc.c main.c pwm.c usb.c timer.c dac.c irq_dma.c port.c ring_buffer.c
    ./inc/: sys_command.h
  group inc
    ./inc/: adc.h main.h pwm.h usb.h timer.h dac.h irq_dma.h port.h ring_buffer.h sys_command.h
software components: Device:Startup 2.2.0i, Drivers:ADC 2.2.0i, Drivers:BKP 2.2.0i, Drivers:DAC 2.2.0i, Drivers:DMA 2.2.0i, Drivers:EEPROM 2.2.0i, Drivers:PORT 2.2.0i, Drivers:POWER 2.2.0i, Drivers:RST_CLK 2.2.0i, Drivers:TIMER 2.2.0i, Drivers:USB Library 2.1.0i, Drivers:USB 2.1.0i, Drivers:UTILS 1.2.0i
